# Keil uVision project 031__STM32F1_USART_UART_SETUP_INIT_LIBRARY_for_USART__INPUT_the_USART_and_BAUD_RATE.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 031__STM32F1_USART_UART_SETUP_INIT_LIBRARY_for_USART__INPUT_the_USART_and_BAUD_RATE
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c gp_driver.c gp_driver.h systick_time.c systick_time.h uart_driver.c uart_driver.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
