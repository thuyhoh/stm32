# Keil uVision project stm32f103_drivers.uvprojx, settings and files
target Application (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103_drivers
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Drivers\include;..\..\CortexMx\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./: main.c main.h
  group Inc
    ../Drivers/include/: CortexMx.h CortexMx_BitBand.h CortexMx_NVIC.h CortexMx_SysTick_Timer.h stm32f103xx.h stm32f103xx_dma_driver.h stm32f103xx_flash_driver.h stm32f103xx_gpio_driver.h stm32f103xx_i2c_driver.h stm32f103xx_rcc_driver.h stm32f103xx_spi_driver.h stm32f103xx_uart_driver.h
  group Drivers
    ../../CortexMx/: CortexMx.c CortexMx_NVIC.c CortexMx_SysTick_Timer.c
    ../Drivers/: stm32f103xx_dma_driver.c stm32f103xx_flash_driver.c stm32f103xx_gpio_driver.c stm32f103xx_i2c_driver.c stm32f407xx_spi_driver.c stm32f103xx_uart_driver.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
