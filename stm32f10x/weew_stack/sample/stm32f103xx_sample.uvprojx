# Keil uVision project stm32f103xx_sample.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103xx_sample
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./: main.c
  group Inc
    ../Drivers/Inc/: gp_drive.h uart_drive.h SPI_drive.h i2c_drive.h adc_drive.h timer_drive.h systick_time.h
  group Drivers
    ../Drivers/Src/: gp_drive.c uart_drive.c SPI_drive.c i2c_drive.c adc_drive.c timer_drive.c systick_time.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
