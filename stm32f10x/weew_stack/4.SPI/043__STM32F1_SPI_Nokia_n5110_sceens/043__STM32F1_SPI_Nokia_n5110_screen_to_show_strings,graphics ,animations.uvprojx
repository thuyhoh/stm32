# Keil uVision project 043__STM32F1_SPI_Nokia_n5110_screen_to_show_strings,graphics ,animations.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 043__STM32F1_SPI_Nokia_n5110_screen_to_show_strings,graphics ,animations
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: gpio_drive.c gpio_drive.h main.c nokia5110lcd.c nokia5110lcd.h SPI_drive.c SPI_drive.h systick_drive.c systick_drive.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
