# Keil uVision project 083.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 083
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\Driver\include;..\..\..\Driver\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./: main.c
  group Drive
    ../../../Driver/: gpio_drive.c systick_time_drive.c timer_drive.c i2c_drive.c dma.c flash.c rtos.asm uart_drive.c
software components: CMSIS:CORE 5.6.0, Device:DMA 1.3, Device:Startup 1.0.0
